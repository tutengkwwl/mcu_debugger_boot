# Keil uVision project PLC.uvprojx, settings and files
target Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F207ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: plc_bootloader
  AfterMake: fromelf.exe --bin --output plc_bootloader_0x8000000.bin  .\Objects\plc_bootloader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_USB_FS
  c include: ..\Drivers\CMSIS\Include;..\Drivers\STM32F2xx_HAL_Driver\Inc;..\Drivers\STM32F2xx_HAL_Driver\Inc\Legacy;..\App;..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\plc_core\inc;..\plc_core\;..\USB_Device_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../Drivers/: startup_stm32f207xx.s
  group HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_dma.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rtc.c stm32f2xx_hal_tim.c stm32f2xx_hal_uart.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_usart.c stm32f2xx_ll_pwr.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_usb.c
  group USB_Device_Library
    ../USB_Device_Library/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_desc.c usbd_conf.c usbd_hid.c
  group PLC_Core
    ../plc_core/src/: hal_debug.c hal_time.c hal_led.c hal_flash.c hal_usb_bulk.c
    ../plc_core/: plc_core_cfg.h
  group App
    ../App/: main.c stm32f2xx_hal_msp.c stm32f2xx_it.c system_stm32f2xx.c
